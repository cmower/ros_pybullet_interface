Commit message: minor change in urdf

File: objects/target_folder/target.urdf (robot description, URDF)
Before this commit: robot target.urdf, 1 links, 0 joints
Links:
- link baseLink: mass 1.0 -> 2.0
